DESCRIPTION = "python3-rpi.gpio"
SECTION = "apps"
HOMEPAGE = "https://pypi.org/project/RPi.GPIO/"
LICENSE = "MIT"

inherit pypi setuptools3

PYPI_PACKAGE = "RPi.GPIO"
LIC_FILES_CHKSUM = "file://LICENCE.txt;md5=9b95630a648966b142f1a0dcea001cb7"
SRC_URI[md5sum] = "777617f9dea9a1680f9af43db0cf150e"
SRC_URI[sha256sum] = "7424bc6c205466764f30f666c18187a0824077daf20b295c42f08aea2cb87d3f"
